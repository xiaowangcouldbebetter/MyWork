# Keil uVision project MBOT.uvprojx, settings and files
target MYCAR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\ENCODER;..\TIM;..\DELAY;..\PWM;..\IO;..\OLED;..\SYS;..\USART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MBOT
    ./: main.c
  group TIM
    ../TIM/: timer.c
  group ENCODER
    ../ENCODER/: encoder.c
  group DELAY
    ../DELAY/: delay.c
  group USART
    ../USART/: usart.c
  group PWM
    ../PWM/: PWM.c
  group MBOT_IO
    ../IO/: MBOT_IO.c
  group OLED
    ../OLED/: oled.c
  group SYS
    ../SYS/: sys.c
software components: CMSIS:CORE 5.3.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
